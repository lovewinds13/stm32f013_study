# Keil uVision project Stm32f10x_Project.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Stm32f10x_Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\App\inc;..\Driver\inc;..\Libraries\CMSIS\Core\inc;..\Libraries\CMSIS\Device\inc;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\HalIterface\inc;..\User\inc;..\Driver\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group User
    ../User/src/: Main.c
  group App
    ../App/src/: app_flash.c variable.c app_adc.c app_htu21d.c app_at24cxx.c logic_grammer.c c_language_regular.c
  group Driver
    ../Driver/src/: sys.c delay.c usart.c hardware_spi.c drvsfspi.c drvsfi2c.c drvexflash.c drvadc.c drvnrf2401.c drvsdcard.c drvuart.c drvled.c drvoled.c drvtimer.c drvexti.c drvfreq.c hcsr04.c drvrtc.c
  group Libraries
    ../Libraries/CMSIS/Core/src/: core_cm3.c
    ../Libraries/CMSIS/Device/src/: stm32f10x_it.c system_stm32f10x.c
    ../Libraries/CMSIS/Device/Startup/: startup_stm32f10x_hd.s
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group HalIterface
    ../HalIterface/src/: hal_spi.c
